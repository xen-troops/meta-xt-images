FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
    file://0001-arm-renesas-Do-not-disable-MSTP3.patch \
"
