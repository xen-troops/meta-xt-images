# Avoid cross dependence on gles-user-module

DEPENDS = "libdrm wayland"
