require inc/agl.inc

XT_AGL_FEATURES += "agl-demo"

XT_BB_IMAGE_TARGET = "agl-demo-platform"

