require inc/agl.inc
require inc/agl_domd.inc

XT_BB_IMAGE_TARGET = "agl-image-minimal"
