require inc/agl.inc

XT_BB_IMAGE_TARGET = "agl-image-weston"

