# Append domain name
hostname .= "-domr"
