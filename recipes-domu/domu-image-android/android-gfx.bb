SUMMARY = "Build graphic binaries required by Android"

LICENSE = "MIT"

