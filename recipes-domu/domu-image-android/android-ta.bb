SUMMARY = "Build trusted applications required by Android"

LICENSE = "MIT"

